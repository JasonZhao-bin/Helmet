# Keil uVision project Project.uvprojx, settings and files
target Project (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ../USER;../LIB/inc;../CMSIS;../../Components/OSAL;../../Components/HAL;../../Components/APP;../../Components/HAL/USB/src;../../Components/HAL/USB/lib;../../Components/HAL/DW/dw_twr;../../Components/HAL/DW/decadriver;../../Components/Main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../../Components/APP/: cmd.c cmd_fn.c Generic.c Generic_cmd.c
  group HAL
    ../../Components/HAL/: hal_led.c hal_drivers.c hal_timer.c hal_usart.c hal_flash.c hal_spi.c
  group OSAL
    ../../Components/OSAL/: OSAL_Comdef.h OSAL.c
  group ZMain
    ../../Components/Main/: main.c stm32f10x_it.c
  group DW/Twr
    ../../Components/HAL/DW/dw_twr/: tag_dist.c tag_pos.c twr_task.c uwb.c instance_common.c instance_anch.c instance_tag.c instance_calib.c deca_mutex.c deca_range_tables.c
  group DW/Driver
    ../../Components/HAL/DW/decadriver/: deca_device.c deca_params_init.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
